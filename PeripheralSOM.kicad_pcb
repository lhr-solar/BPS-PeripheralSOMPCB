# Repository lhr-solar/BPS-PeripheralSOMPCB

## KiCad design PeripheralSOM.kicad_pcb

Board: 4 copper layers, 53.5 x 37.8 mm, 116 parts (37 on the bottom side), 80 nets.

Parts:
C1, C2, C9, C19, C26: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C8, C10, C18, C20, C23, C29, C34, C35: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C24, C27, C28, C31, C33: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 3.3nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C11, C12, C14, C15, C16, C17, C25, C36: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C30, C32: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22: 12p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CR1, CR2: D5V0P4UR6SO-7
D1: MBR230S1F; D_SOD-123F
D2: TVS; D_SOD-323_HandSoldering
D3: CFLT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: Heartbeat; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5, D15: 1N5819HW; D_SOD-123
D6: SP0503BAHTG; SOT-143
D7: 24V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9: PFLT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: TVS; D_SOD-123F
D11: BUCK; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: LED2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13: LED1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D14: LED0; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1, FB4: FerriteBead; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: SWD; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
J2: USB4215-03-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J4: 52465-2470; 524652470
JP1: TRM; PinHeader_1x02_P2.54mm_Vertical
L1: 100uH; L_Coilcraft_MSS1246-XXX
LOGO2: LHRs; LHRs_LOGO
MH1, MH2, MH3, MH4: M3; MountingHole_3.2mm_M3_Pad_TopBottom
R1, R4, R9, R10, R23, R27, R29, R33: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: ROSC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 16k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7, R11, R17, R18, R26: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 332; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 45.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 590; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R16: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 2.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 402k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R28: 4.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30: 19k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R31: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 768; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RST; SW_TL3365AF180QG
SW2: BOOT; SW_CJS-1200TA
TP1: 24V_EXT; TestPoint_Pad_1.0x1.0mm
TP2: 24V; TestPoint_Pad_1.0x1.0mm
TP3: 5V_BK; TestPoint_Pad_1.0x1.0mm
TP4: 5V_USB; TestPoint_Pad_1.0x1.0mm
TP6: 3V3; TestPoint_Pad_1.0x1.0mm
TP7, TP8: GND; TestPoint_Pad_1.0x1.0mm
U1: STM32L431CBTx; LQFP-48_7x7mm_P0.5mm
U2: TPS5405DR
U3: LT1963AEST-3.3#TRPBF; SOT-223-3_TabPin2
U4: TCAN337; TCAN337DCNR
U5: CDSOT23-T24CAN
U6: TPS2115ADRBR; VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm
U7: LM76202QPWPRQ1
U8: CP2102N-A02-GQFN24
U9: 74AHC1G32; SOT-23-5
Y1: 8M; Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm

Connections:
+3.3V: C13.1, C14.1, C16.1, C17.1, C19.1, C24.1, C30.1, C31.1, C32.1, C33.1, C36.1, CR1.5, CR2.5, D15.1 (K), FB4.1, J1.1, J4.2, R4.1, R21.1, R23.1, R26.1, R29.1, SW2.1 (A), TP6.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.3 (VCC), U8.5 (VIO), U8.6 (VDD), U8.7 (VREGIN), U9.5 (VCC)
+5V: C10.1, C26.1, R9.1, R32.1, U3.1 (IN), U6.7 (OUT)
+5V_BUCK: C8.1, C27.1, C34.1, C35.1, L1.2, TP3.1, U2.5 (VSENSE), U6.8 (IN1)
+5V_VBUS: C28.1, C29.1, D5.1 (K), D6.4 (K), R22.1, TP4.1, U6.6 (IN2)
+24V: C2.1, C3.1, C9.1, C23.1, R1.1, R25.1, R28.1, TP2.1, U2.2 (VIN), U7.15 (OUT_1), U7.16 (OUT_2)
+24V_EXT: C1.1, C20.1, D2.2 (A2), J4.24, R12.1, TP1.1, U7.1 (IN_1), U7.2 (IN_2)
/CAN/CAN1_RX: U1.45 (PB8), U4.4 (RXD)
/CAN/CAN1_TX: U1.46 (PB9), U4.1 (TXD)
/CAN/FAULT: R4.2, R5.1, U4.5 (FAULT)
/CAN_H: J4.22, R7.1, U4.7 (CANH), U5.1 (CAN_H)
/CAN_L: J4.20, JP1.2 (B), U4.6 (CANL), U5.2 (CAN_L)
/LEDs/LED1: R18.1, U1.17 (PA7)
/LEDs/LED2: R17.1, U1.29 (PA8)
/LEDs/LED3: R6.1, U1.38 (PA15)
/LEDs/LED_HB: R11.1, U1.22 (PB11)
/MCU/ADC1_IN7: J4.9, U1.12 (PA2)
/MCU/ADC1_IN9: J4.11, U1.14 (PA4)
/MCU/ADC1_IN10: J4.13, U1.15 (PA5)
/MCU/ADC1_IN11: J4.15, U1.16 (PA6)
/MCU/ADC1_IN16: D10.1 (K), R31.2, U1.19 (PB1)
/MCU/BOOT0: R10.1, U1.44 (PH3)
/MCU/BOOT_GPIO: R33.1, U1.40 (PB4), U9.2
/MCU/BOOT_SW: SW2.2 (B), U9.1
/MCU/I2C1_SCL: J4.6, U1.42 (PB6)
/MCU/I2C1_SDA: J4.4, U1.43 (PB7)
/MCU/NRST: C11.1, R29.2, SW1.1, U1.7 (NRST)
/MCU/OSC_IN: C21.1, U1.5 (PH0), Y1.1
/MCU/OSC_OUT: C22.1, U1.6 (PH1), Y1.2
/MCU/SPI1_MISO: CR2.6, J4.21, U1.32 (PA11)
/MCU/SPI1_MOSI: CR2.4, J4.17, U1.33 (PA12)
/MCU/SPI1_NSS: CR2.1, J4.19, U1.18 (PB0)
/MCU/SPI1_SCK: CR2.3, J4.23, U1.39 (PB3)
/MCU/SPI2_MISO: CR1.1, J4.14, U1.27 (PB14)
/MCU/SPI2_MOSI: CR1.6, J4.16, U1.28 (PB15)
/MCU/SPI2_NSS: CR1.3, J4.12, U1.25 (PB12)
/MCU/SPI2_SCK: CR1.4, J4.18, U1.21 (PB10)
/MCU/SWCLK: J1.2, U1.37 (PA14)
/MCU/SWDIO: J1.4, U1.34 (PA13)
/MCU/USART1_RX: U1.31 (PA10), U8.21 (TXD)
/MCU/USART1_TX: U1.30 (PA9), U8.20 (RXD)
/OPAMP1_VINP: J4.7, U1.10 (PA0)
/PowerDist/FAULT: D9.1 (K), R1.2, U7.14 (~FLT)
/PowerDist/ILIM: R8.1, U6.4 (ILIM)
/PowerDist/LDO_3V3: C18.1, D15.2 (A), U3.3 (OUT)
/PowerDist/PowerProtection/ILIM: R27.1, U7.11 (ILIM)
/PowerDist/PowerProtection/IMON: R30.1, R31.1, U7.10 (IMON)
/PowerDist/PowerProtection/MODE: R20.1, U7.6 (MODE)
/PowerDist/PowerProtection/OVP: R13.2, R15.1, U7.5 (OVP)
/PowerDist/PowerProtection/RTN: C25.2, R15.2, R20.2, R27.2, R30.2, U7.8 (RTN), U7.17 (EP)
/PowerDist/PowerProtection/SHDN: R23.2, U7.7 (~SHDN)
/PowerDist/PowerProtection/UVLO: R12.2, R13.1, U7.3 (UVLO)
/PowerDist/ROSC: R2.1, U2.3 (ROSC)
/PowerDist/STAT: D11.1 (K), R9.2, U6.1 (STAT)
/USB/CC1: J2.A5 (CC1), R14.1
/USB/CC2: J2.B5 (CC2), R16.1
/USB/D+: D6.2 (K), J2.A6 (D+), J2.B6 (D+), U8.3 (D+)
/USB/D-: D6.3 (K), J2.A7 (D-), J2.B7 (D-), U8.4 (D-)
/USB/RST: R21.2, U8.9 (~RST)
/USB/VBUS: R22.2, R24.1, U8.8 (VBUS)
/USB/VBUS_IN: D5.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
GND: C1.2, C2.2, C3.2, C5.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, CR1.2, CR2.2, D1.2 (A), D2.1 (A1), D3.1 (K), D4.1 (K), D6.1 (A), D7.1 (K), D8.1 (K), D10.2 (A), D12.1 (K), D13.1 (K), D14.1 (K), FB1.1, J1.3, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J4.1, J4.3, J4.5, R2.2, R3.2, R8.2, R14.2, R16.2, R24.2, R33.2, SW1.2, SW2.3 (C), TP7.1, TP8.1, U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.7 (GND), U3.2 (GND), U4.2 (GND), U5.3 (GND), U6.3 (D1), U6.5 (GND), U6.9 (EXP), U7.9 (GND), U8.2 (GND), U8.25 (GND), U9.3 (GND)
GNDA: C7.2, C12.2, C15.2, FB1.2, J4.10, U1.8 (VSSA)
unnamed: C6.2, R3.1
unnamed: C4.2, D1.1 (K), L1.1, U2.8 (LX)
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R11.2
unnamed: D7.2 (A), R25.2
unnamed: D8.2 (A), R26.2
unnamed: D9.2 (A), R28.2
unnamed: D11.2 (A), R32.2
unnamed: D12.2 (A), R6.2
unnamed: D13.2 (A), R17.2
unnamed: D14.2 (A), R18.2
unnamed: JP1.1 (A), R7.2
unnamed: R10.2, U9.4
unnamed: C4.1, U2.1 (BOOT)
unnamed: C6.1, U2.6 (COMP)
unnamed: C5.1, U2.4 (SS)
unnamed: C25.1, U7.12 (DVDT)
VDDA: C7.1, C12.1, C15.1, FB4.2, J4.8, U1.9 (VDDA)

File jlcpcb/production_files/BOM-PeripheralSOM.csv:

Comment,Designator,Footprint,LCSC,Quantity
100k,,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C100048,0
1k,R21,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C103209,1
45.3k,R12,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C103650,1
5.1k,"R14,R16",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C105580,2
3.3nF,C6,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C107088,1
4.3k,"R25,R28",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C137712,2
16k,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C137788,1
TPS2115ADRBR,U6,VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm,C140321,1
8M,Y1,Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm,C144380,1
LT1963AEST-3.3#TRPBF,U3,SOT-223-3_TabPin2,C145411,1
100nF,"C11,C12,C14,C15,C16,C17,C24,C25,C27,C28,C31,C33,C36,C4,C7",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663,15
MBR230S1F,D1,D_SOD-123F,C151335,1
1uF,"C1,C19,C2,C26,C9",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849,5
LM76202QPWPRQ1,U7,LM76202QPWPRQ1,C1849484,1
TVS,D2,D_SOD-323_HandSoldering,C207246,1
120,"R11,R17,R18,R26,R5,R6,R7",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22787,7
590,R13,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C227973,1
19k,R30,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22897,1
2.1k,R15,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22902,1
332,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23007,1
402k,R20,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23048,1
768,R32,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23108,1
10k,"R1,R10,R23,R27,R29,R33,R4,R9",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25804,8
47k,R24,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25819,1
TCAN337,U4,TCAN337DCNR,C2671619,1
STM32L431CBTx,U1,LQFP-48_7x7mm_P0.5mm,C277951,1
BOOT,SW2,SW_CJS-1200TA,C2921628,1
CDSOT23-T24CAN,U5,CDSOT23-T24CAN,C2959841,1
22k,R22,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C31850,1
FerriteBead,"FB1,FB4",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C354394,2
12p,"C21,C22",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C38523,2
USB4215-03-A,J2,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,C393939,1
TPS5405DR,U2,TPS5405DR,C488409,1
D5V0P4UR6SO-7,"CR1,CR2",D5V0P4UR6SO-7,C531179,2
10nF,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C57112,1
10uF,"C10,C18,C20,C23,C29,C3,C34,C35,C8",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,C6119889,9
TVS,D10,D_SOD-123F,C6165153,1
SP0503BAHTG,D6,SOT-143,C7074,1
BUCK,"D11,D12,D13,D14,D4,D7,D8",LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,7
74AHC1G32,U9,SOT-23-5,C7470,1
1N5819HW,"D15,D5",D_SOD-123,C82544,2
CFLT,"D3,D9",LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C84263,2
RST,SW1,SW_TL3365AF180QG,C92589,1
CP2102N-A02-GQFN24,U8,CP2102N-A02-GQFN24,C969151,1
4.7uF,"C13,C30,C32",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,C98192,3
SWD,J1,Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical,,1
100uH,L1,L_Coilcraft_MSS1246-XXX,,1
TRM,JP1,PinHeader_1x02_P2.54mm_Vertical,,1

## Code that names these connections

File CubeMX/CubeMX.ioc (part):

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Mcu.Name=STM32L431C(B-C)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32L431CBTx
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB10.Signal=S_TIM2_CH3
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=80000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2026-03-09 laksee
